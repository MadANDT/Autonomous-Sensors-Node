<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STOP1_WL55_1CPU.ewp</path>
  </project>
  <batchBuild />
</workspace>
